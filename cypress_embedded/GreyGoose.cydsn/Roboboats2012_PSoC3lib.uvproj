# Keil uVision project Roboboats2012_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Roboboats2012_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h RC_ReceiverBus_aliases.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c Timer_1.c Timer_1.h Timer_1_PM.c CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h timer_clock.c timer_clock.h Clock_1.c Clock_1.h isr_RC1N.c isr_RC1N.h isr_RC2N.c isr_RC2N.h isr_RC3N.c isr_RC3N.h isr_RC4N.c isr_RC4N.h isr_RC5N.c isr_RC5N.h isr_RC6N.c isr_RC6N.h isr_RC7N.c isr_RC7N.h Tx_RBTQ2.c Tx_RBTQ2.h Tx_RBTQ2_aliases.h UART_RBTQ1.c UART_RBTQ1.h UART_RBTQ1_PM.c UART_RBTQ1_INT.c UART_RBTQ2.c UART_RBTQ2.h UART_RBTQ2_PM.c UART_RBTQ2_INT.c Rx_RBTQ1.c Rx_RBTQ1.h Rx_RBTQ1_aliases.h Tx_RBTQ1.c Tx_RBTQ1.h Tx_RBTQ1_aliases.h Rx_RBTQ2.c Rx_RBTQ2.h Rx_RBTQ2_aliases.h isr_Rx.c isr_Rx.h isr_RC1P.c isr_RC1P.h isr_RC2P.c isr_RC2P.h isr_RC3P.c isr_RC3P.h isr_RC4P.c isr_RC4P.h isr_RC5P.c isr_RC5P.h isr_RC6P.c isr_RC6P.h isr_RC7P.c isr_RC7P.h strobe.c strobe.h strobe_aliases.h status_1.c status_1.h status_1_aliases.h ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c VIN_aliases.h AMux_1.c AMux_1.h Actuator_aliases.h UART_SABERTOOTH.c UART_SABERTOOTH.h UART_SABERTOOTH_PM.c UART_SABERTOOTH_INT.c ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h BATT_MOTOR_aliases.h BATT_LOGIC_aliases.h DieTemp_1.c DieTemp_1.h buzzer.c buzzer.h buzzer_aliases.h Comp_1.c Comp_1.h Comp_1_PM.c Reset_Ref_aliases.h Reset_aliases.h status_2.c status_2.h status_2_aliases.h pump.c pump.h pump_aliases.h external.c external.h external_aliases.h buzzerControl.c buzzerControl.h nerf_fire.c nerf_fire.h nerf_fire_aliases.h nerf_reed.c nerf_reed.h nerf_reed_aliases.h nerf_int.c nerf_int.h LaunchSol.c LaunchSol.h LaunchSol_aliases.h ArmExtended_switch.c ArmExtended_switch.h ArmExtended_switch_aliases.h ArmRetracted_switch.c ArmRetracted_switch.h ArmRetracted_switch_aliases.h ArmExtendedInt.c ArmExtendedInt.h ArmRetractedInt.c ArmRetractedInt.h UART_1_BOOT.c UART_RBTQ1_BOOT.c UART_RBTQ2_BOOT.c VIN.c VIN.h Actuator.c Actuator.h UART_SABERTOOTH_BOOT.c BATT_MOTOR.c BATT_MOTOR.h BATT_LOGIC.c BATT_LOGIC.h Reset_Ref.c Reset_Ref.h Reset.c Reset.h UART_1_IntClock.c UART_1_IntClock.h UART_RBTQ1_IntClock.c UART_RBTQ1_IntClock.h UART_RBTQ2_IntClock.c UART_RBTQ2_IntClock.h UART_SABERTOOTH_IntClock.c UART_SABERTOOTH_IntClock.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Roboboats2012_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
